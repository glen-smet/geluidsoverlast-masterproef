# Keil uVision project Sgfx_push_button.uvprojx, settings and files
target mlm32l07x01 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DISCO_CUBE_SGFX_WLIB +hex
  AfterMake: C:\Keil_v5\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bincombined --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: DEBUG,STM32L072xx,USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, USE_RADIO_LL_DRIVER, USE_HAL_DRIVER, REGION_EU868, DEVICE_3, NBIOT_ORANGE, LORAWAN_TTN
  c misc: --C99
  c include: ..\inc;..\Core\inc;..\Drivers\BSP\MLM32L07X01;..\Drivers\BSP\Components\sx1276;..\Drivers\STM32L0xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\Drivers\CMSIS\Include;..\Middlewares\Utilities;..\Middlewares\Third_Party\Sgfx\SigfoxLib;..\Middlewares\Third_Party\LoRaWAN\Crypto;..\Middlewares\Third_Party\LoRaWAN\Mac;..\Middlewares\Third_Party\LoRaWAN\Phy;..\Middlewares\Third_Party\LoRaWAN\Patterns\Basic;..\Divers\BSP\Components\Common;..\Middlewares\Third_Party\Sgfx\Crypto;..\Drivers\BSP\Components;..\Drivers\BSP\B-L072Z-LRWAN1;..\Drivers\BSP\X_NUCLEO_IKS01A2;..\Common\cwmx1zzabz\Radio_Sigfox_Driver;..\Common\cwmx1zzabz\Credentials_libs;..\Drivers\BSP\Components\Common;..\Drivers\BSP\Components\hts221;..\Drivers\BSP\Components\lps22hb;..\Drivers\BSP\Components\lps25hb;..\Drivers\BSP\B-L072Z-LRWAN1;..\Middlewares\Third_Party\LoRaWAN\Mac\Region;..\Middlewares\Third_Party\LoRaWAN\Utilities;..\Drivers\STM32L0xx_HAL_Driver\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x17000
  memory RVCT5: ROM 0x8017000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\NUCLEO_CUBE_SGFX.sct
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/BSP/B-L072Z-LRWAN1
    ../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Drivers/BSP/MLM32L0X01
    ../Drivers/BSP/MLM32L07X01/: mlm32l07x01.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx/HAL
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_rcc.c stm32l0xx_ll_dma.c stm32l0xx_ll_spi.c stm32l0xx_hal_rng.c stm32l0xx_hal_wwdg.c stm32l0xx_hal_iwdg.c
  group Projects/MDK-ARM
    ./: startup_stm32l072xx.s
  group Middlewares/Utilities
    ../Middlewares/Utilities/: low_power_manager.c queue.c systime.c timeServer.c trace.c utilities.c scheduler.c
  group Middlewares/Sigfox/Lib
    ../Middlewares/Third_Party/Sgfx/SigfoxLib/: SgfxCoreV231_CM0_Keil.lib
    ../Middlewares/Third_Party/Sgfx/SigfoxLibTest/: SgfxAddonV020_CM0_Keil.lib
  group Middlewares/Sigfox/Crypto
    ../Middlewares/Third_Party/Sgfx/Crypto/: SgfxCmacV100_CM0_Keil_O3.lib sigfox_data.c se_nvm.c
  group Middlewares/LoRaWAN/Mac
    ../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
  group Middlewares/LoRaWAN/Mac/Regions
    ../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group Middlewares/LoRaWAN/Crypto
    ../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
  group Middlewares/LoRaWAN/Patterns/Basic
    ../Middlewares/Third_Party/LoRaWAN/Patterns/Basic/: lora.c lora-test.c
  group src
    ../src/: debug.c hw_gpio.c hw_rtc.c hw_spi.c vcom.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c hw_tim2.c tiny_sscanf.c tiny_vsnprintf.c hw_eeprom.c bsp.c bg96.c vcom2.c util.c ltc2942.c bq27441.c energy.c lorawan.c nbiot.c sigfox.c main.c spiram.c microFFT.c
    ../Common/cwmx1zzabz/Radio_Sigfox_Driver/: mcu_api.c rf_api.c st_lowlevel.c SgfxSTModemSx1276V123_CM0_Keil_O3.lib
    ../Common/cwmx1zzabz/Credentials_libs/: SgfxCredentialsV011_CM0_Keil_O3.lib
